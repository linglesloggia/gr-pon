options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: bwmap
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '3000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/4moulins/projects/gr-pon/misc/raw_captures/raw_1onuTCONT1MAXBW.gpon
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: pon_gpon_bwmap_parser_0
  id: pon_gpon_bwmap_parser
  parameters: {}
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', pon_gpon_bwmap_parser_0, '0']
- [pon_gpon_bwmap_parser_0, out, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-980-g25047da6
