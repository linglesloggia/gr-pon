options:
  parameters:
    author: Lucas Inglés
    generate_options: qt_gui
    id: full_pon_demod
    output_language: python
    title: gr-pon
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 5e9
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/4moulins/projects/gr-pon/sandbox/gnu_output/102056.bin
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/4moulins/projects/ecoc2026/output
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/4moulins/projects/exp_20260401_171520_54/scope_captures/captura_pon_us_ch2_20260401_171554_f32.f32
    repeat: 'False'
    type: float
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '0'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 2.5e9
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: 0.2e9
    win: window.WIN_HAMMING
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pon_gpon_bwmap_parser_0
  id: pon_gpon_bwmap_parser
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Filtered signal"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '0.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Raw signal"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '0.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Sync signal"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '0.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Sync signal"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '0.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '31250'
    interp: 972*32
    type: fff
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_char_0, '0', pon_gpon_bwmap_parser_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle2_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_char_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_throttle2_0, '0', low_pass_filter_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_1, '0']
- [digital_binary_slicer_fb_0, '0', blocks_file_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', pon_gpon_bwmap_parser_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_threshold_ff_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0_1, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_1_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_1, '0']
- [pon_gpon_bwmap_parser_0, out, blocks_message_debug_0, print]
- [pon_gpon_bwmap_parser_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [rational_resampler_xxx_0, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
